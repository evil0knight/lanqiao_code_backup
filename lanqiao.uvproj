# Keil uVision project lanqiao.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 12.15test2_ +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\test2
  group USER
    ./: main.c
  group BSP
    ./: seg.c seg.h tim.c tim.h key.c key.h iic.c iic.h ds1302.c ds1302.h onewire.c onewire.h
